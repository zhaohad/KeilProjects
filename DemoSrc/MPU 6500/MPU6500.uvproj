# Keil uVision project MPU6500.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MPU6500 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./src/: delay.c delay.h oled12864.c oled12864.h oled12864wordlib.h typedef.h uart.c uart.h mpu6500.c mpu6500.h I2CBus.c I2CBus.h
