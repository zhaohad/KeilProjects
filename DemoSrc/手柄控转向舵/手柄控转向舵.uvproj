# Keil uVision project 手柄控转向舵.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 手柄控转向舵 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 DigitalDisplay_8.c DigitalDisplay_8.h I2CBus.c I2CBus.h main.c SteeringSG90.h SteeringSG90.c HandleControl.h HandleControl.c
