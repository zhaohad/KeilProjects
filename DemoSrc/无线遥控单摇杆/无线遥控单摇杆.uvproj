# Keil uVision project 无线遥控单摇杆.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 无线遥控单摇杆 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c delay.h G01_S.c G01_S.h main.c spi.c spi.h typedef.h I2CBus.c I2CBus.h HandleControl.h HandleControl.c SteeringSG90.h SteeringSG90.c hw.h
