# Keil uVision project 自平衡自行车.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 自平衡自行车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Config.h main.c shanwai.c shanwai.h STC8A_GPIO.c STC8A_GPIO.h STC8A_NVIC.c STC8A_NVIC.h STC8A_Switch.h STC8A_UART.c STC8A_UART.h STC8A_UART_Isr.c STC8A8K64D4.H Type_def.h typedef.h uart.c uart.h STC8A_I2C.c STC8A_I2C.h STC8A_Timer.c STC8A_Timer.h STC8A_Timer_Isr.c Task.c Task.h app.h mpu6500.c mpu6500.h servo.c servo.h STC8A_PWM15bit.c STC8A_PWM15bit.h STC8A_PWM15bit_Isr.c oled12864.c oled12864.h oled12864wordlib.h delay.c delay.h
