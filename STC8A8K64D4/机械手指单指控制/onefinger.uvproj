# Keil uVision project onefinger.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: onefinger +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c STC8A_GPIO.h typedef.h Type_def.h RZ7899.c RZ7899.h STC8A_GPIO.c oled12864.c oled12864.h delay.c delay.h oled12864wordlib.h STC8A_ADC.c STC8A_ADC_Isr.c STC8A_ADC.h rotationCounter.c rotationCounter.h Config.h STC8A8K64D4.H dtos.c dtos.h test.c test.h
