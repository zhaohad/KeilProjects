# Keil uVision project mpu6500.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: mpu6500 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./src/: typedef.h app.h
  group stc
    ./src/stc/: STC8A_GPIO.c STC8A_GPIO.h STC8A8K64D4.H Type_def.h STC8A_I2C.c STC8A_I2C.h STC8A_I2C_Isr.c STC8A_NVIC.c STC8A_NVIC.h STC8A_Switch.h STC8A_Timer.c STC8A_Timer.h STC8A_Timer_Isr.c Config.h Task.h Task.c
  group uart
    ./src/uart/: uart.h uart.c
  group 12864
    ./src/12864/: oled12864.c oled12864.h oled12864wordlib.h
  group com
    ./src/com/: delay.c delay.h
  group mpu6500
    ./src/mpu6500/: mpu6500.c mpu6500.h
  group I2CBus
    ./src/I2CBus/: I2CBus.c I2CBus.h
