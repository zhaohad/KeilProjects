# Keil uVision project 硬件ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 硬件ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: app.h Config.h delay.c delay.h main.c STC8A_GPIO.c STC8A_GPIO.h STC8A_PWM15bit.c STC8A_PWM15bit.h STC8A_PWM15bit_Isr.c STC8A_Switch.h STC8A8K64D4.H Type_def.h typedef.h STC8A_ADC.c STC8A_ADC.h
