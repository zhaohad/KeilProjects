# Keil uVision project shanwai.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: shanwai +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c STC8A_NVIC.c STC8A_NVIC.h STC8A_UART.c STC8A_UART.h Type_def.h typedef.h STC8A_GPIO.c STC8A_GPIO.h STC8A_UART_Isr.c STC8A8K64D4.H Config.h STC8A_Switch.h uart.c uart.h shanwai.c shanwai.h
