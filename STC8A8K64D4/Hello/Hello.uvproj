# Keil uVision project Hello.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Hello +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: STARTUP.A51 main.c
  group stc
    ./src/stc/: STC8A_GPIO.c STC8A_GPIO.h STC8A8K64D4.H Type_def.h
