# Keil uVision project G01_S.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: G01_S +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: delay.c delay.h main.c STC8A_GPIO.c STC8A_GPIO.h STC8A8K64D4.H typedef.h G01_S.c G01_S.h Type_def.h spi.c spi.h oled12864.c oled12864.h oled12864wordlib.h dtos.c dtos.h
