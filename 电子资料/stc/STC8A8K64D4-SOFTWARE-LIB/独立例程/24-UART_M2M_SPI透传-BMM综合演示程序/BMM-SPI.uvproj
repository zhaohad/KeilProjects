# Keil uVision project BMM-SPI.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: BMM-SPI +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: isr.asm main.c STC8A_GPIO.c STC8A_NVIC.c STC8A_BMM.c STC8A_BMM_Isr.c STC8A_UART.c STC8A_UART_Isr.c STC8A_SPI.c STC8A_SPI_Isr.c
