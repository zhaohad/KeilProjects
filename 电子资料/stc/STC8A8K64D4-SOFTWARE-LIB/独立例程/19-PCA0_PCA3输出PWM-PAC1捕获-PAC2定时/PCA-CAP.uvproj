# Keil uVision project PCA-CAP.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: PCA-CAP +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8A_Delay.c STC8A_GPIO.c STC8A_NVIC.c STC8A_PCA.c STC8A_PCA_Isr.c STC8A_UART.c STC8A_UART_Isr.c
