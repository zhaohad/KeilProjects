# Keil uVision project STC8A-LIB.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8A-LIB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver\inc;..\User;..\App\inc
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c system_init.c Task.c isr.asm
  group APP
    ../App/src/: APP.c APP_INT_UART1.c APP_AD_UART.c APP_Lamp.c APP_RTC.c APP_I2C_PS.c APP_SPI_PS.c APP_WDT.c APP_EEPROM.c APP_PCA_PWM.c APP_PCA_Capture.c APP_PWM15bit.c APP_BMM_AD.c APP_BMM_M2M.c APP_BMM_UART.c APP_BMM_SPI_PS.c APP_BMM_LCM.c
  group Driver
    ../Driver/src/: STC8A_ADC.c STC8A_Compare.c STC8A_Delay.c STC8A_EEPROM.c STC8A_Exti.c STC8A_GPIO.c STC8A_I2C.c STC8A_NVIC.c STC8A_PCA.c STC8A_PWM15bit.c STC8A_Soft_I2C.c STC8A_Soft_UART.c STC8A_SPI.c STC8A_Timer.c STC8A_UART.c STC8A_WDT.c STC8A_BMM.c STC8A_LCM.c
  group ISR
    ../Driver/isr/: STC8A_ADC_Isr.c STC8A_Compare_Isr.c STC8A_Exti_Isr.c STC8A_GPIO_Isr.c STC8A_I2C_Isr.c STC8A_PCA_Isr.c STC8A_PWM15bit_Isr.c STC8A_SPI_Isr.c STC8A_Timer_Isr.c STC8A_UART_Isr.c STC8A_BMM_Isr.c
