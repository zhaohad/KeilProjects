# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: PWM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: GPIO.c main.c timer.c PWM.C
