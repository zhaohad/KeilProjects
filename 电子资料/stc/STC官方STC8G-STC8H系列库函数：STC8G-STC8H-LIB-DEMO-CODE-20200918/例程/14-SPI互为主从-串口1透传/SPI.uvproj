# Keil uVision project SPI.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: SPI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c spi.c main.c UART.C GPIO.c
