# Keil uVision project RF24L01_89C52.uvproj, settings and files
target RF24L01 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RF24L01_89C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source_File\app\inc;.\Source_File\drv_mcu\inc;.\Source_File\drv_periph\inc
  group app
    ./Source_File/app/src/: main.c
    ./Source_File/app/inc/: main.h
  group drv_periph
    ./Source_File/drv_periph/src/: drv_RF24L01.c
    ./Source_File/drv_periph/inc/: drv_RF24L01.h
  group drv_muc
    ./Source_File/drv_mcu/src/: drv_button.c drv_delay.c drv_led.c drv_spi.c drv_uart.c
    ./Source_File/drv_mcu/inc/: drv_button.h drv_delay.h drv_led.h drv_spi.h drv_uart.h typedef.h
