# Keil uVision project 舵机控制计时器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 舵机控制计时器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: app.h Config.h delay.c delay.h main.c STC8A_GPIO.c STC8A_GPIO.h STC8A8K64D4.H Type_def.h typedef.h STC8A_Timer_Isr.c STC8A_Timer.h STC8A_Timer.c STC8A_NVIC.c STC8A_NVIC.h servo_t0.c servo_t0.h servo_t1.c servo_t1.h action.h action.c action_def.h action_def.c G01_S.c G01_S.h spi.c spi.h oled12864.c oled12864.h oled12864wordlib.h dtos.c dtos.h communication_protocol.c communication_protocol.h
