# Keil uVision project multiuart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: CH9329 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Config.h delay.c delay.h main.c oled12864.c oled12864.h oled12864wordlib.h STC8A_GPIO.c STC8A_GPIO.h STC8A_NVIC.c STC8A_NVIC.h STC8A_SPI.c STC8A_SPI.h STC8A_SPI_Isr.c STC8A8K64D4.H Type_def.h typedef.h 74HC595.c 74HC595.h 74HC165.c 74HC165.h STC8A_UART.c STC8A_UART.h STC8A_UART_Isr.c STC8A_Switch.h CH9239.c CH9239.h key_board.c key_board.h main.h
