# Keil uVision project multiuart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: multiuart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: delay.c delay.h main.c typedef.h dtos.c dtos.h STC8xxxx.H GPIO.c GPIO.h config.h UART.C UART.h CarCtrl.c CarCtrl.h timer.c timer.h
