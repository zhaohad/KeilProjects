# Keil uVision project multiuart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: multiuart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Config.h delay.c delay.h main.c oled12864.c oled12864.h oled12864wordlib.h STC8A_GPIO.c STC8A_GPIO.h STC8A_NVIC.c STC8A_NVIC.h STC8A_SPI.c STC8A_SPI.h STC8A_SPI_Isr.c STC8A8K64D4.H Type_def.h typedef.h uart.c uart.h STC8A_ADC.c STC8A_ADC.h STC8A_Switch.h dtos.c dtos.h G01_S.c G01_S.h spi.c spi.h global_status.c global_status.h STC8A_Timer.c STC8A_Timer.h STC8A_Timer_Isr.c joinstick.c joinstick.h communication_protocol.c communication_protocol.h
