# Keil uVision project uart_send.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W Series STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: uart_send +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c uart.h typedef.h delay.h delay.c
